# Repository jspspike/balance

## KiCad design pcb/balance.kicad_pcb

Parts:
C1, C2, C3, C4, C7: .1uF; C_0805_2012Metric
C5, C6, C8: 3.3uF; C_0805_2012Metric
C9, C10: 10pF; C_0805_2012Metric
C11: 0.1uF; C_0805_2012Metric
C12, C13, C14: 10uF; C_0805_2012Metric
D1: LED_GREEN; LED_0603_1608Metric_Castellated
D2: LED_BLUE; LED_0603_1608Metric_Castellated
D3: LED_RED; LED_0603_1608Metric_Castellated
J1: Resistive_Touch; TE_84952-4_1x04-1MP_P1.0mm_Horizontal
J2: JTAG; PinHeader_1x05_P2.54mm_Vertical
J3: Conn_01x04_Male; PinHeader_1x04_P2.54mm_Vertical
J4: PJ-102AH; CUI_PJ-102AH
J5: UART (Bluetooth); PinSocket_1x04_P2.54mm_Horizontal
J6: Conn_02x03_Top_Bottom; PinHeader_2x03_P2.54mm_Vertical
J7: Conn_02x05_Top_Bottom; PinHeader_2x05_P2.54mm_Vertical
LS1: CMT-8530S-SMT; CUI_CMT-8530S-SMT
M1, M2: Motor_Servo; PinHeader_1x03_P2.54mm_Vertical
Q1, Q2, Q3: MMBT3904; SOT-23
R1: 1Mohm; R_0805_2012Metric
R2, R7: 68ohm; R_0805_2012Metric
R3: 10k; R_0805_2012Metric
R4, R5, R8: 100ohm; R_0805_2012Metric
R6: 50ohm; R_0805_2012Metric
SW1: SW_Push; SW_SMD_2-1437565-8_4_4.50_6.00_6.00_5.00
U1: TM4C123GH6PMI; QFP50P1200X1200X160-64N
U2: LM2937xS; TO-263-3_TabPin2
Y1: 16MHz; Crystal_SMD_5032-2Pin_5.0x3.2mm

Connections:
+3V3: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C12.1, J6.5, LS1.P, R1.2, R2.1, R3.1, R6.1, R7.1, U1.2, U1.11, U1.26, U1.37, U1.42, U1.54, U2.3 (VO)
+5V: C11.1, C13.2, C14.2, J4.1, J5.1, M1.2 (+), M2.2 (+), U2.1 (VI)
/BZZZ: R4.2, U1.60
/Blue: R5.2, U1.59
/OSC0: C10.1, U1.40, Y1.2
/OSC1: C9.2, U1.41, Y1.1
/PA2: J7.1, U1.19
/PA3: J7.2, U1.20
/PA4: J7.3, U1.21
/PA5: J7.4, U1.22
/PA6: J7.5, U1.23
/PA7: J7.6, U1.24
/PC4: J7.7, U1.16
/PC7: J7.10, U1.13
/PD0: J6.1, U1.61
/PD1: J6.2, U1.62
/PD2: J6.3, U1.63
/PD3: J6.4, U1.64
/RESET: R3.2, SW1.2, U1.38
/RX: J5.3, U1.17
/Red: R8.1, U1.30
/Servo0: M1.1 (PWM), U1.58
/Servo1: M2.1 (PWM), U1.1
/TX: J5.4, U1.18
GND: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.2, C11.2, C12.2, C13.1, C14.1, D1.1 (K), J2.5, J4.2, J5.2, J6.6, M1.3 (-), M2.3 (-), Q1.2 (E), Q2.2 (E), Q3.2 (E), SW1.1, U1.3, U1.12, U1.27, U1.35, U1.39, U1.55, U2.2 (GND)
unnamed: C7.2, C8.2, U1.25, U1.56
unnamed: D1.2 (A), R2.2
unnamed: D2.1 (K), Q2.3 (C)
unnamed: D2.2 (A), R6.2
unnamed: D3.1 (K), Q3.3 (C)
unnamed: D3.2 (A), R7.2
unnamed: J1.1 (X1), J3.4, U1.6
unnamed: J1.2 (Y1), J3.3, U1.7
unnamed: J1.3 (X2), J3.2, U1.8
unnamed: J1.4 (Y2), J3.1, U1.9
unnamed: J2.1, U1.52
unnamed: J2.2, U1.51
unnamed: J2.3, U1.50
unnamed: J2.4, U1.49
unnamed: LS1.N, Q1.3 (C)
unnamed: Q1.1 (B), R4.1
unnamed: Q2.1 (B), R5.1
unnamed: Q3.1 (B), R8.2
unnamed: R1.1, U1.32

Notes on the sheet:
less than 3 ohm ESR required

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
Board: 2 copper layers, 67.0 x 55.0 mm, 42 parts (0 on the bottom side), 46 nets.

## Commit log

2019-10-25 AP2114
2019-10-25 Made lib folder
2019-10-25 Added schematic
2019-10-25 Added pcb
2019-10-25 remove prolog
2019-10-29 Redo schematic in kicad
    Components are placed but not routed yet
2019-10-31 Modify component placement and fix transistor circuits
2019-10-31 Route the board
2019-11-01 Add mounting holes and remove some vias
2019-11-02 test
2019-11-02 finished report
2019-11-02 added names to report
2019-11-02 added BOM
2019-11-24 Add test code for servos
2019-11-25 Fix PWM bugs
    Manual servo control works
2019-12-04 Added screen interface
2019-12-04 added adc to main
2019-12-04 adc_init complete
2019-12-04 Added pid
2019-12-04 change to software trigger
2019-12-05 Added more pid
2019-12-05 Added buffer
2019-12-05 Add screen breakout
2019-12-10 Rewrite code
2019-12-11 Get LEDs and speaker working on actual board
2019-12-17 Add setpoints and mess with velocity control
2019-12-17 Add more setpoints and start on motion profiles
2019-12-17 Small tweaks for submission
